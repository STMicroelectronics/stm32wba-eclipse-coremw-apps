# IAR project Ux_Device_HID.ewp, settings and files
configuration Ux_Device_HID (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: UX_INCLUDE_USER_DEFINE_FILE; USE_HAL_DRIVER; STM32WBA65xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../USBX/App; ../USBX/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\..\..\..\Middlewares\ST\usbx\ports\freertos\inc; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: Ux_Device_HID.hex
  ILINK.IlinkOutputFile: Ux_Device_HID.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_hal_timebase_tim.c stm32wbaxx_it.c
  group Application/User/USBX/App
    ../USBX/App/: app_usbx.c app_usbx_device.c ux_device_descriptors.c ux_device_mouse.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pcd.c stm32wbaxx_hal_pcd_ex.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_usb.c
  group Middlewares/FreeRTOS/Core
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/FreeRTOS/MemMang.Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/USBX/Core System
    ../../../../../../Middlewares/ST/usbx/ports/freertos/src/: ux_os_utility_event_flags_create.c ux_os_utility_event_flags_delete.c ux_os_utility_event_flags_get.c ux_os_utility_event_flags_set.c ux_os_utility_mutex_create.c ux_os_utility_mutex_delete.c ux_os_utility_mutex_off.c ux_os_utility_mutex_on.c ux_os_utility_semaphore_create.c ux_os_utility_semaphore_delete.c ux_os_utility_semaphore_get.c ux_os_utility_semaphore_put.c ux_os_utility_sleep_ms.c ux_os_utility_thread_create.c ux_os_utility_thread_delete.c ux_os_utility_thread_identify.c ux_os_utility_thread_relinquish.c ux_os_utility_thread_resume.c ux_os_utility_thread_schedule_other.c ux_os_utility_thread_sleep.c ux_os_utility_thread_suspend.c ux_os_utility_timer_create.c ux_os_utility_timer_delete.c ux_os_utility_timer_start.c
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/UX Device Class HID
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_interrupt_thread.c ux_device_class_hid_read.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_thread.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_uninitialize.c
  group Middlewares/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
